# For some reason my ssh stops working.
# Lets see if root login fix works.
                                                                                                                                                                                         
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
                                                                                                                                                                                                        
SRC_URI += "file://sshd_config"