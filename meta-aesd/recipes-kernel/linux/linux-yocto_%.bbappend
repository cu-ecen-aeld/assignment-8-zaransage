FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://disable-faulty.cfg"